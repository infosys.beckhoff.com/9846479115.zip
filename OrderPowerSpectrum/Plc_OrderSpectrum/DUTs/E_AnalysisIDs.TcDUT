TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_PwrSpec,
	eID_Sink_PwrSpec,
	eID_SourcePaired,
	eID_OrderSpec,
	eID_Sink_OrderSpec
) UDINT;
END_TYPE
